# Keil uVision project atk_mp1_m4.uvprojx, settings and files
target DHT11 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32MP157DAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: atk_mp1_m4
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32MP157Dxx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32MP1xx\Include;..\..\Drivers\STM32MP1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Core_A\Include;..\..\Drivers\CMSIS\Core\Include;..\..\Middlewares
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: ..\..\User\SCRIPT\stm32mp15xx_m4.sct
  link misc: --diag_suppress=6314
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32MP1xx/Source/Templates/arm/: startup_stm32mp15xx.s
  group User
    ../../User/: main.c stm32mp1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32MP1xx/Source/Templates/: system_stm32mp1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_usart.c stm32mp1xx_hal_usart_ex.c stm32mp1xx_hal_wwdg.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_rng.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/DMA/: dma.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/DAC/: dac.c
    ../../Drivers/BSP/AP3216C/: ap3216c.c
    ../../Drivers/BSP/IIC/: iic.c
    ../../Drivers/BSP/PCF8563/: pcf8563.c
    ../../Drivers/BSP/DS18B20/: ds18b20.c
    ../../Drivers/BSP/DHT11/: dht11.c
  group Middleware/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Readme
    ../../: readme.txt
