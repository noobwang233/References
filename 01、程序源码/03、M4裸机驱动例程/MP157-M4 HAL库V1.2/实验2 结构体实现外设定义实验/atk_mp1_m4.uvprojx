# Keil uVision project atk_mp1_m4.uvprojx, settings and files
target LED_STRUCT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32MP157DAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: atk_mp1_m4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp15xx_m4.sct
  link misc: --diag_suppress=6314
  group source
    ./: startup_stm32mp15xx.s main.c readme.txt
